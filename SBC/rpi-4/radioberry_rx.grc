options:
  parameters:
    author: Anton Janovsky (ZR6AIC)
    description: Radioberry RX
    generate_options: qt_gui
    id: RadioberryRX
    output_language: python
    title: RadioberryRX
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: note_0
  id: note
  parameters:
    note: sample rate [48000.000000, 384000.000000]
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    ant0: ANTENNA RX
    ant1: ANTENNA RX
    args: driver=radioberry
    balance0: '0'
    center_freq0: 7.07e6
    center_freq1: 14.07e6
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    dc_removal1: 'False'
    dev: driver=radioberry
    devname: custom
    overall_gain0: '100'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
